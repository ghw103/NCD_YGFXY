/***************************************************************************************************
*FileName: Md5FileDao
*Description: 保存新程序文件的MD5值
*Author: xsx_kair
*Data: 2017年2月16日15:23:25
***************************************************************************************************/

/***************************************************************************************************/
/******************************************Header List********************************************/
/***************************************************************************************************/
#include	"Md5FileDao.h"

#include	"CRC16.h"
#include	"MyMem.h"

#include	"ff.h"

#include	<string.h>
#include	"stdio.h"
#include 	"stdlib.h"
/***************************************************************************************************/
/***************************************************************************************************/
/***************************************************************************************************/


/***************************************************************************************************/
/***************************************************************************************************/
/***************************************************************************************************/

/***************************************************************************************************/
/***************************************************************************************************/
/***************************************************************************************************/
/****************************************File Start*************************************************/
/***************************************************************************************************/
/***************************************************************************************************/
/***************************************************************************************************
*FunctionName: WriteMd5File
*Description: 更新文件的md5
*Input: md5Str -- md5字符串
*Output: 
*Return: 
*Author: xsx
*Date: 2017年2月16日15:25:32
***************************************************************************************************/
MyState_TypeDef WriteMd5File(char * md5Str)
{
	FatfsFileInfo_Def * myfile = NULL;
	MyState_TypeDef statues = My_Fail;
	
	myfile = MyMalloc(sizeof(FatfsFileInfo_Def));
	
	if(myfile && md5Str)
	{
		memset(myfile, 0, sizeof(FatfsFileInfo_Def));

		myfile->res = f_open(&(myfile->file), "0:/md5.txt", FA_OPEN_ALWAYS | FA_WRITE | FA_READ);

		if(FR_OK == myfile->res)
		{	
			f_lseek(&(myfile->file), 0);
			
			myfile->res = f_write(&(myfile->file), md5Str, 32, &(myfile->bw));
			if(myfile->res == FR_OK)
				statues = My_Pass;
			
			f_close(&(myfile->file));
		}
	}
	
	MyFree(myfile);
	
	return statues;
}

/***************************************************************************************************
*FunctionName: ReadMd5File
*Description: 读取文件的md5值
*Input: md5Str -- 读取缓存
*Output: 
*Return: 
*Author: xsx
*Date: 2017年2月16日15:25:44
***************************************************************************************************/
MyState_TypeDef ReadMd5File(char * md5Str)
{
	FatfsFileInfo_Def * myfile = NULL;
	MyState_TypeDef statues = My_Fail;
	
	myfile = MyMalloc(sizeof(FatfsFileInfo_Def));
	
	if(myfile && md5Str)
	{
		memset(myfile, 0, sizeof(FatfsFileInfo_Def));

		myfile->res = f_open(&(myfile->file), "0:/md5.txt", FA_OPEN_EXISTING | FA_READ);

		if(FR_OK == myfile->res)
		{	
			f_lseek(&(myfile->file), 0);
			
			myfile->res = f_read(&(myfile->file), md5Str, 32, &(myfile->br));
			if(myfile->res == FR_OK)
				statues = My_Pass;
			
			f_close(&(myfile->file));
		}
	}
	
	MyFree(myfile);
	
	return statues;
}

/****************************************end of file************************************************/
